# Repository GCY/Continuous-Non-Invasive-Blood-Pressure-Research-Platform---ECG-and-PPG-Pulse-Arrival-Time-Based-

File README.md:

# Continuous Non-Invasive Blood Pressure Research Platform - ECG and PPG Pulse Arrival Time Based
This project is cuffless cNIBP research platform with ECG(two-electrode, without Right Leg Drive(RLD) ) and PPG(MAX3010x),  the Pulse Arrival Time (PAT) using ECG and PPG signal, measure the time delay(∆t) between QRS-Complex of the ECG signal and any one systolic peak of the PPG signal.

## Hardware

### V4

coming soon...

- STM32F405
- ECG : INA333+AD8669(without RLD)
- Electrode : PCB Pads and NeuroSky EEG dry 6mm electrode(Pinhole PAD1 & PAD2) [NeuroSky](http://neurosky.com)
- PPG : LArm
- LCM : 128x64 SSD1306
- OUTPUT : USB-FS VCP
- Charger : BQ24014

### V3

- STM32F405
- ECG : INA827+LM324PWR(without RLD)
- Electrode : PCB Pads and NeuroSky EEG dry 6mm electrode(Pinhole PAD1 & PAD2) [NeuroSky](http://neurosky.com)
- PPG : LArm
- LCM : 128x64 SSD1306
- OUTPUT : USB-FS VCP
- Charger : TP4056*

#### Note
- TP4056 have mV level peak-to-peak noise... so, jump VBUS to switch... 
- Replace D1 to 0R resistor, reduce LDO VDDA noise.
- Unplug the NB AC adapter.

</br>

### V1
- STM32F407
- ECG : INA827+LM324PWR(without RLD)
- Electrode : PCB Pads
- PPG : LArm and RArm
- LCM : 128x64 SSD1306
- OUTPUT : UART

## Firmware
This firmware only for testing, includes USB-FS VCP, Max3010x Spo2 algorithm, PPG and ECG signal oscilloscope display.</br>

 - cd ./firmware/stm32f405/src/
 - make
 - load elf file
 - run
## Software
[wxECGAnalyzer](https://github.com/GCY/wxECGAnalyzer) is a QRS-Complex ECG signal process tool and QRS-Complex detection algorithm validation tools, [Pulse Oximeter MAX3010X](https://github.com/GCY/Pulse-Oximeter-with-MAX3010X) is a Spo2 signal process and r-ratio finetune tool, combining the two tools, could implement the PAT-BP regression algorithm.

</br>

## Pulse Arrival Time Calculate

## What's cuff-less blood pressure monitor and difference between Pulse Arrival Time(PAT) and Pulse Transit Time(PTT)
In cuffless non-invasive blood pressure monitor field, we with the accurate calibration of PAT to BP, beat-to-beat BP can be estimated from PAT. On the basis of the theoretical relationship between PAT and BP and their experimental or empirical relationship, various models that correlate PAT with BP have been established.</br>
</br>
PAT and BP with Regression: </br>

</br>
</br>
Pulse transit time (PTT) is the time it takes for the pressure or flow wave to propagate between two arterial sites.
PTT measured as the time delay between invasive proximal and distal blood pressure or flow, and PTT(propagate time) can be converted to Pulse Wave Velocity(PWV is speed unit).

the most used is the R-wave(QRS Complex) in the electrocardiogram (ECG) and combine pulsemeter(piezo or PPG), leading to the so called pulse arrival time (PAT). 
PAT is not exactly the PTT, as it includes the time interval between ventricular depolarization and the opening of the aortic valve which is known as pre-ejection period (PEP) and it varies beat-to-beat.

Most efforts have employed the time delay between ECG and finger photoplethysmography (PPG) waveforms as a convenient surrogate of PTT. 

However, these conventional pulse arrival time (PAT) measurements include the pre-ejection period (PEP) and the time delay through small,
muscular arteries and may thus be an unreliable marker of BP.

Shortcoming is that PAT includes the pre-ejection period (PEP) in addition to PTT. 
Since the PEP component depends on the electromechanical functioning of the heart, it can change independently of PTT and thus BP. 

Because the ECG QRS-Complex is not the starting point for blood to actually enter the radial artery, it is a biopotential to depolarization of the sinus node

</br>

## This project only for research

</br>

</br>

## Reference :
- [1] Continuous Blood Pressure Measurement from Invasive to Unobtrusive: Celebration of 200th Birth Anniversary of Carl Ludwig</br>
- [2] Cuff-Less and Continuous Blood Pressure Monitoring: A Methodological Review</br>
- [3] https://www.egr.msu.edu/classes/ece480/capstone/spring13/group03/documents.html
- [4] Cho, J., & Baek, H. J. (2020). A Comparative Study of Brachial–Ankle Pulse Wave Velocity and Heart–Finger Pulse Wave Velocity in Korean Adults. Sensors, 20(7), 2073.
 
LICENSE
-------

MIT License

Copyright (c) 2020 Tony Guo

Permission is hereby granted, free of charge, to any person obtaining a copy
of this software and associated documentation files (the "Software"), to deal
in the Software without restriction, including without limitation the rights
to use, copy, modify, merge, publish, distribute, sublicense, and/or sell
copies of the Software, and to permit persons to whom the Software is
furnished to do so, subject to the following conditions:

The above copyright notice and this permission notice shall be included in all
copies or substantial portions of the Software.

THE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR
IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE
AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER
LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM,
OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE
SOFTWARE.

OSHW Certification
-------

https://certification.oshwa.org/tw000003.html

## EAGLE design ECG AFE Board/ECG/ECG/ECG.brd

File ECG AFE Board/README.md:

# ECG Analog-Front-End Design

two electrode ECG without RLD

Parts:
C1: 2.2uF; CAP-PTH-LARGE
C2, C3, C4, C5, C6, C7, C8, C10, C11: 0.1uF; CAP-PTH-LARGE
C9, C12: 0.22uF; CAP-PTH-LARGE
IC1, IC2: LM324D; SO14
JP1, JP3: PINHD-1X2; 1X02
JP2: USB-MICROB
R1, R2: 10k; AXIAL-0.4
R3: 1k; AXIAL-0.4
R4, R5: 1.8M; AXIAL-0.4
R6: 5.1k; AXIAL-0.4
R7, R8, R12, R17, R21: 12k; AXIAL-0.4
R9: 100k; AXIAL-0.4
R10, R11: 15k; AXIAL-0.4
R13: 5.6k; AXIAL-0.4
R14, R15, R18, R19: 27k; AXIAL-0.4
R16, R20: 9.1k; AXIAL-0.4
U$1: OPA330-SC70-5
U$2: INA827
U$3: PJ-327A

Connections:
GND: C1.2, C2.2, C6.1, IC1.11 (V-), IC2.11 (V-), JP1.2, JP2.GND, JP2.MT1 (GND), JP2.MT2 (GND), JP3.2, R2.P$1 (1), R5.P$2 (2), R7.P$2 (2), R8.P$2 (2), R12.P$2 (2), R16.P$2 (2), R20.P$2 (2), U$1.2 (2.V-), U$2.5 (5.-VS), U$3.3 (3-GND), U$3.4 (4-GND)
L_ARM: U$2.1 (1.-IN), U$3.2 (2-OUTL), U$3.6 (6-OUTL)
unnamed: R1.P$1 (1), R2.P$2 (2), U$1.1 (1.+IN)
unnamed: R3.P$2 (2), U$2.2 (2.RG)
unnamed: R3.P$1 (1), U$2.3 (3.RG)
unnamed: C4.2, IC1.3 (+IN), R5.P$1 (1)
unnamed: C3.1, U$2.7 (7.VOUT)
unnamed: C3.2, C4.1, R4.P$2 (2)
unnamed: IC1.1 (OUT), IC1.5 (+IN), R4.P$1 (1), R6.P$1 (1)
unnamed: IC1.2 (-IN), R6.P$2 (2), R7.P$1 (1)
unnamed: C5.1, R10.P$1 (1), R11.P$2 (2)
unnamed: IC1.6 (-IN), R8.P$1 (1), R9.P$2 (2)
unnamed: IC1.7 (OUT), R9.P$1 (1), R10.P$2 (2)
unnamed: C6.2, IC1.12 (+IN), R11.P$1 (1)
unnamed: C5.2, C7.1, IC1.14 (OUT), R13.P$1 (1), R14.P$2 (2)
unnamed: IC1.13 (-IN), R12.P$1 (1), R13.P$2 (2)
unnamed: C9.1, R14.P$1 (1), R15.P$2 (2)
unnamed: C8.2, IC2.3 (+IN), R15.P$1 (1)
unnamed: C7.2, C8.1, R16.P$1 (1)
unnamed: IC2.2 (-IN), R17.P$1 (1)
unnamed: C9.2, C11.1, IC2.1 (OUT), R17.P$2 (2), R18.P$2 (2)
unnamed: IC2.13 (-IN), R21.P$1 (1)
unnamed: C10.1, C11.2, R20.P$1 (1)
unnamed: C10.2, IC2.12 (+IN), R19.P$1 (1)
unnamed: C12.1, R18.P$1 (1), R19.P$2 (2)
unnamed: C12.2, IC2.14 (OUT), JP3.1, R21.P$2 (2)
REF_GND: U$1.3 (3.-IN), U$1.4 (4.OUT), U$2.6 (6.REF)
R_ARM: U$2.4 (4.+IN), U$3.5 (5-OUTR)
VCC: C1.1, C2.1, IC1.4 (V+), IC2.4 (V+), JP1.1, JP2.VBUS, R1.P$2 (2), U$1.5 (5.V+), U$2.8 (8.+VS)

Board: 2 copper layers, 41 parts (0 on the bottom side), 29 nets, no tracks yet.

## EAGLE design ECG AFE Board/ECG/ECG V2/ECG.brd

Parts:
C1, C2, C3, C4, C13, C14, C15, C16, C17, C18: 0.1uF; 0603-CAP
C5, C6: 0.22uF; 0603-CAP
C7: 1nF; 0603-CAP
IC1, IC2: LM324D; SO14
JP1, JP3: PINHD-1X2; 1X02
LED1: LEDCHIPLED_0603; CHIPLED_0603
R1, R4, R8, R13, R16: 12k; 0603-RES
R2, R3: 1.8M; 0603-RES
R5: 100k; 0603-RES
R6, R7: 7.5k; 0603-RES
R9: 5.6k; 0603-RES
R10, R11, R14, R15: 27k; 0603-RES
R12, R17: 9.1k; 0603-RES
R18: 0; 0603-RES
R19, R22, R23: 10k; 0603-RES
R20: 1M; 0603-RES
R21: 100; 0603-RES
R24, R25: 499; 0603-RES
R26: 5.1k; 0603-RES
U1: USB""; USB-MICRO-SMD
U$1: OPA330-SC70-5
U$2: INA827
U$3: PJ-327A

Connections:
GND: C4.1, C13.2, C14.2, IC1.3 (+IN), IC1.11 (V-), IC2.11 (V-), JP1.2, JP3.2, LED1.C, R1.1, R3.1, R4.1, R8.1, R12.1, R17.1, R23.1, U1.GND1 (GND), U$1.2 (2.V-), U$2.5 (5.-VS)
L_ARM: U$2.1 (1.-IN), U$3.2 (2-OUTL), U$3.6 (6-OUTL)
unnamed: R22.1, R23.2, U$1.1 (1.+IN)
unnamed: R24.2, U$2.2 (2.RG)
unnamed: R25.2, U$2.3 (3.RG)
unnamed: C2.2, IC1.5 (+IN), R3.2
unnamed: C1.1, U$2.7 (7.VOUT)
unnamed: C1.2, C2.1, R2.1
unnamed: IC1.7 (OUT), IC1.10 (+IN), R2.2, R26.2
unnamed: IC1.6 (-IN), R1.2, R26.1
unnamed: C3.1, R6.2, R7.1
unnamed: IC1.9 (-IN), R4.2, R5.1
unnamed: IC1.8 (OUT), R5.2, R6.1
unnamed: C4.2, IC1.12 (+IN), R7.2
unnamed: C3.2, C15.1, IC1.14 (OUT), R9.2, R10.1
unnamed: IC1.13 (-IN), R8.2, R9.1
unnamed: C5.1, R10.2, R11.1
unnamed: C16.2, IC2.3 (+IN), R11.2
unnamed: C15.2, C16.1, R12.2
unnamed: IC2.2 (-IN), R13.2
unnamed: C5.2, C17.1, IC2.1 (OUT), R13.1, R15.1
unnamed: IC2.13 (-IN), R16.2
unnamed: C17.2, C18.1, R17.2
unnamed: C18.2, IC2.12 (+IN), R14.2
unnamed: C6.1, R14.1, R15.2
unnamed: C6.2, IC2.14 (OUT), JP3.1, R16.1, R21.2
unnamed: R18.2, R24.1, R25.1
unnamed: IC1.2 (-IN), R18.1, R19.1, R20.1
unnamed: C7.1, R19.2
unnamed: LED1.A, R21.1
REF_GND: U$1.3 (3.-IN), U$1.4 (4.OUT), U$2.6 (6.REF)
R_ARM: U$2.4 (4.+IN), U$3.5 (5-OUTR)
TP7: C7.2, IC1.1 (OUT), R20.2, U$3.3 (3-GND), U$3.4 (4-GND)
VCC: C13.1, C14.1, IC1.4 (V+), IC2.4 (V+), JP1.1, R22.2, U1.VBUS1 (VBUS), U$1.5 (5.V+), U$2.8 (8.+VS)

Notes on the sheet:
TP7 = LEG

Board: 2 copper layers, 48 parts (19 on the bottom side), 34 nets, no tracks yet.

## EAGLE design ECG AFE Board/two electrode ECG/two electrode ECG/two electrode ECG.brd

Parts:
C1, C2, C3, C4, C6, C7, C8, C9, C15, C16: 0.1uF; 0603-CAP
C5: 0.22uF; 0603-CAP
IC1, IC2: LM324D; SO14
JP1: Battery; 1X02
JP2: PINHD-1X2; 1X02
JP3: Output; 1X02
R1, R4, R8, R13: 12k; 0603-RES
R2, R3: 1.8M; 0603-RES
R5: 100k; 0603-RES
R6, R7: 7.5k; 0603-RES
R9: 5.6k; 0603-RES
R10, R11: 27k; 0603-RES
R12: 9.1k; 0603-RES
R14: 1M; 0603-RES
R15, R16, R26: 5.1k; 0603-RES
R17: 100; 0603-RES
R18, R19: 10k; 0603-RES
R20: 51k; 0603-RES
R21, R22: 220k; 0603-RES
R23, R24: 2M; 0603-RES
U$1, U$3: CAPSENSE_PAD
U$2: INA827

Connections:
GND: C4.1, C8.1, C9.1, IC1.11 (V-), IC2.11 (V-), JP1.2, JP3.2, R1.1, R3.1, R4.1, R8.1, R12.1, R19.1, U$2.5 (5.-VS)
LARM: JP2.1, R21.1, U$1.P$2 (RES)
unnamed: R20.2, U$2.2 (2.RG)
unnamed: C6.2, IC2.2 (-IN), R14.1
unnamed: R14.2, R15.1, U$2.7 (7.VOUT)
unnamed: C2.2, IC1.3 (+IN), R3.2
unnamed: R21.2, R23.2, U$2.1 (1.-IN)
unnamed: C1.2, C2.1, R2.1
unnamed: IC1.1 (OUT), IC1.5 (+IN), R2.2, R26.2
unnamed: IC1.2 (-IN), R1.2, R26.1
unnamed: C3.1, R6.2, R7.1
unnamed: IC1.6 (-IN), R4.2, R5.1
unnamed: IC1.7 (OUT), R5.2, R6.1
unnamed: C4.2, IC1.10 (+IN), R7.2
unnamed: C3.2, C15.1, IC1.8 (OUT), R9.2, R10.1
unnamed: IC1.9 (-IN), R8.2, R9.1
unnamed: C5.1, R10.2, R11.1
unnamed: C16.2, IC1.12 (+IN), R11.2
unnamed: C15.2, C16.1, R12.2
unnamed: IC1.13 (-IN), R13.2
unnamed: C5.2, IC1.14 (OUT), JP3.1, R13.1
unnamed: C6.1, IC2.1 (OUT), U$2.6 (6.REF)
unnamed: C7.1, IC2.6 (-IN), R15.2, R16.1
unnamed: C7.2, IC2.7 (OUT), R16.2, R17.1
unnamed: C1.1, C8.2, R17.2
unnamed: C9.2, IC2.3 (+IN), IC2.5 (+IN), R18.1, R19.2, R23.1, R24.1
unnamed: R20.1, U$2.3 (3.RG)
unnamed: R22.2, R24.2, U$2.4 (4.+IN)
RARM: JP2.2, R22.1, U$3.P$2 (RES)
VCC: IC1.4 (V+), IC2.4 (V+), JP1.1, R18.2, U$2.8 (8.+VS)

Notes on the sheet:
R21,R22 Input Impedance調整
INA Gain調整24k
要改5k，否則PORST會消失

Board: 2 copper layers, 45.8 x 38.7 mm, 44 parts (21 on the bottom side), 30 nets.

## EAGLE design PCB/v3/NICBP v3.brd

Parts:
BAT1: BATTERYLIPO-TABS; LIPO-110-TABS
C29: 100uF; NIPPON_F80
C38, C39: 10uF/10v; EIA3216-KIT
C40: 0.1uF; 0603-CAP
D5, D6: BLUE; LED-0603
R62: 2K; 0603-RES
R63, R64, R66: 1K; 0603-RES
R65: 100R; 0603-RES
SW1: SMD-TOGGLE-SWITCH-2CH(2X3P-7X3.5MM); SW6-2.54-SMD-7.0X3.5X1.5MM
T1: DMN3024LSD; TSSOP-8
U$6: TP4056; SOT23-8
U$7: DW01; SOT23-6

Connections:
GND: C38.C (-), C39.C (-), R62.1, R66.1, T1.6 (S), T1.7 (S), U$6.1 (TEMP), U$6.3 (GND); also elsewhere on the board
unnamed: BAT1.+, C29.+, C39.A (+), R65.2, SW1.COM1, U$6.5 (BAT)
unnamed: R62.2, U$6.2 (PROG)
unnamed: R63.1, U$6.7 (!CHRG)
unnamed: R64.1, U$6.6 (!STDBY)
unnamed: D6.C, R63.2
unnamed: D5.C, R64.2
unnamed: C40.1, R65.1, U$7.5 (VCC)
unnamed: BAT1.-, C29.-, C40.2, T1.2 (S), T1.3 (S), U$7.6 (GND)
unnamed: T1.4 (G), U$7.1 (0D)
unnamed: R66.2, U$7.2 (CS)
unnamed: T1.1 (D), T1.8 (D)
unnamed: T1.5 (G), U$7.3 (0C)
VBUS: C38.A (+), D5.A, D6.A, U$6.4 (VCC), U$6.8 (CE); also elsewhere on the board
VCC: SW1.CH1A; also elsewhere on the board

Parts:
C5, C6, C7, C8, C9, C12, C13, C14, C15, C22, C23, C24, C41: 0.1uf; C0603
C10, C11: 1uf; C0603
C16, C17: 2.2uf; C0603
C18, C19: 22pF; C0603
C20, C21: 12.5pF; C0603
D1: BAT20JFILM; SOD-323
D2, D3: BLUE; LED-0603
IC1: LD398530RM; SOT23-5L
IC4: LDO_1V8; SOT223
JP2: PINHD-1X4; 1X04
R4, R46: 1k; 0603
R5, R7, R8, R44: 10k; 0603
R6, R45: 10k(N.M); 0603
R14, R15: 22R; 0603-RES
R42, R43: 0; 0603-RES
S1, S2: TAC_SWITCHSMD; TACTILE_SWITCH_SMD
U1: USB""; USB-MICRO-SMD
U$2: NX5032CA-8MHZ
U$3, U$15: FCM1608KF-601T03
U$4: 32.768KHZ-FC-135
U$9: STM32F405R; TQFP64

Connections:
1V8: C24.2, IC4.2 (OUT), IC4.4 (OUT); also elsewhere on the board
B1: C41.1, R8.1, S2.1, S2.2, U$9.14 (PA0/ADC123_IN0(5T))
BAT: U$9.9 (PC1/ADC123_IN11(5T)); also elsewhere on the board
BOOT0: R5.2, R6.2, U$9.60 (BOOT0)
BOOT1: R44.2, R45.2, U$9.28 (PB2/BOOT1(5T))
ECG: U$9.8 (PC0/ADC123_IN10(5T)); also elsewhere on the board
GND: C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.2, C17.2, C18.1, C19.1, C20.1, C21.1, C22.2, C23.1, C24.1, C41.2, D2.C, D3.C, IC1.2 (GND), IC4.1 (ADJ), JP2.2, R5.1, R44.1, S1.3, S1.4, S2.3, S2.4, U1.GND, U1.GND1 (GND), U$9.12 (VSSA), U$9.18 (VSS_1), U$9.63 (VSS_2); also elsewhere on the board
I2C2_SCL: U$9.29 (PB10/I2C2_SCL(5T)); also elsewhere on the board
I2C2_SDA: U$9.30 (PB11/I2C2_SDA(5T)); also elsewhere on the board
I2C3_SCL: U$9.41 (PA8/TIM1_CH1(5T)); also elsewhere on the board
I2C3_SDA: U$9.40 (PC9/TIM3_CH4/TIM8_CH4(5T)); also elsewhere on the board
INT_EXTI12: U$9.33 (PB12(5T)); also elsewhere on the board
LED1: R46.2, U$9.53 (PC12(5T))
LED2: R4.2, U$9.2 (PC13(5T))
MCU_3V3: C8.2, C9.2, C10.2, C11.2, C23.2, D1.1 (C), IC4.3 (IN), R6.1, R7.2, R8.2, R45.1, U$3.1 (1.IN), U$9.1 (VBAT), U$9.19 (VDD_1), U$9.32 (VDD_2), U$9.48 (VDD_3), U$9.64 (VDD_4); also elsewhere on the board
unnamed: D2.A, R4.1
unnamed: C17.1, U$9.31 (VCAP_1)
unnamed: C16.1, U$9.47 (VCAP_2)
unnamed: C6.2, IC1.4 (BYPASS)
unnamed: C7.2, D1.2 (A), IC1.5 (VO)
unnamed: R14.2, U1.D-1 (D-)
unnamed: R15.2, U1.D+1 (D+)
unnamed: R43.2, U1.ID1 (USBID)
unnamed: U1.VBUS1 (VBUS), U$15.1 (1.IN)
unnamed: R42.2, U$15.2 (2.OUT)
unnamed: D3.A, R46.1
NRST: C22.1, R7.1, S1.1, S1.2, U$9.7 (NRST)
OSC32_IN: C21.2, U$4.1 (1.XIN), U$9.3 (PC14/OSC32_IN(5T))
OSC32_OUT: C20.2, U$4.2 (2.XIN), U$9.4 (PC15/OSC32_OUT(5T))
OSC_IN: C19.2, U$2.1 (1.XIN), U$9.5 (PH0/OSC_IN(5T))
OSC_OUT: C18.2, U$2.2 (2.XOUT), U$9.6 (PH1/OSC_OUT(5T))
OTG_FS_DM: R14.1, U$9.44 (PA11/TIM1_CH4/CANRX/USBDM(5T))
OTG_FS_DP: R15.1, U$9.45 (PA12/CANTX/USBDP(5T))
OTG_FS_ID: R43.1, U$9.43 (PA10/TIM1_CH3/USART1_RX(5T))
SWTCK: JP2.3, U$9.49 (PA14/JTCK-SWCLK(5T))
SWTDIO: JP2.4, U$9.46 (PA13/JTMS-SWDAT(5T))
VBUS: R42.1, U$9.42 (PA9/TIM1_CH2/USART1_TX(5T)); also elsewhere on the board
VCC: C5.2, IC1.1 (VIN), IC1.3 (VINH), JP2.1; also elsewhere on the board
VDDA: C12.2, C13.2, C14.2, C15.2, U$3.2 (2.OUT), U$9.13 (VDDA)

Parts:
C4, C25, C26, C27, C28, C30, C31, C32, C33, C34: 0.1uf; C0603
C35: 0.22uf; C0603
PAD1, PAD2: 3,17/1,3
R1, R2: 1M; TRIMPOT_TC33
R3: 100k; TRIMPOT_TC33
R9: 0R; 0603
R10: 0R(N.M); 0603
R16: 1M; 0603
R17, R18, R27: 5.1k; 0603
R19, R20: 10k; 0603
R21, R22: 2M; 0603
R23: 100; 0603
R24, R25: 1.8M; 0603
R26, R28, R32, R37: 12k; 0603
R29: 100k; 0603
R30, R31: 7.5k; 0603
R33: 5.6k; 0603
R34, R35: 27k; 0603
R36: 9.1k; 0603
R47: 1.6M; 0603
R48: 4.3M; 0603
R49: 0; 0603
U4, U5: LM324PW-TSSOP14; TSSOP14-0.65-5X4.4MM
U$5: INA827
U$8, U$10: CAPSENSE_PAD

Connections:
ADC1: C35.2, R37.2, R49.1, U5.14 (OUT2)
AGND: C26.2, C27.2, C31.2, R9.2, R10.2, R20.2, R24.2, R26.1, R28.1, R32.1, R36.1, R48.1, U4.11 (GND), U5.11 (GND), U$5.5 (5.-VS)
BAT: U4.8 (OUT2), U4.9 (-IN2); also elsewhere on the board
ECG: R49.2; also elsewhere on the board
GND: R9.1, R10.1; also elsewhere on the board
L_ARM: PAD2.1, R1.2 (WIPER), U$10.P$1 (RECEIVE), U$10.P$2 (RES)
MCU_3V3: R19.1, U4.4 (+V), U5.4 (+V), U$5.8 (8.+VS); also elsewhere on the board
unnamed: C27.1, C28.1, R23.1
unnamed: R47.1, R48.2, U4.10 (+IN2)
unnamed: R3.3 (CW), U$5.3 (3.RG)
unnamed: R3.2 (WIPER), U$5.2 (2.RG)
unnamed: R1.1 (CCW), R22.2, U$5.1 (1.-IN)
unnamed: R2.1 (CCW), R21.2, U$5.4 (4.+IN)
unnamed: C4.2, U4.1 (OUT1), U$5.6 (6.REF)
unnamed: C4.1, R16.2, U4.2 (-IN1)
unnamed: R16.1, R17.2, U$5.7 (7.VOUT)
unnamed: C25.2, R17.1, R18.2, U4.6 (-IN2)
unnamed: C25.1, R18.1, R23.2, U4.7 (OUT2)
unnamed: C26.1, R19.2, R20.1, R21.1, R22.1, U4.3 (+IN1), U4.5 (+IN2)
unnamed: R26.2, R27.2, U5.2 (-IN1)
unnamed: R25.2, R27.1, U5.1 (OUT1), U5.5 (+IN2)
unnamed: C30.2, R24.1, U5.3 (+IN1)
unnamed: C28.2, C30.1, R25.1
unnamed: R28.2, R29.2, U5.6 (-IN2)
unnamed: R29.1, R30.1, U5.7 (OUT2)
unnamed: C32.1, R30.2, R31.1
unnamed: C31.1, R31.2, U5.10 (+IN2)
unnamed: C32.2, C34.1, R33.2, R34.1, U5.8 (OUT2)
unnamed: R32.2, R33.1, U5.9 (-IN2)
unnamed: C35.1, R34.2, R35.1
unnamed: C33.1, C34.2, R36.2
unnamed: C33.2, R35.2, U5.12 (+IN2)
unnamed: R37.1, U5.13 (-IN2)
R_ARM: PAD1.1, R2.2 (WIPER), U$8.P$1 (RECEIVE), U$8.P$2 (RES)
VCC: R47.2; also elsewhere on the board

Parts:
C1: 0.1uf; C0603
C2, C36, C37: 1uf; C0603
C3: 4.7uf; C0603
R11, R12, R13, R40, R41: 4.7k; 0603
R38: 10k; 0603
R39: 390k; 0603
U$12: MAX30100
U$13: ER-OLED0.96

Connections:
1V8: U$12.11 (VDD); also elsewhere on the board
GND: C1.1, C3.1, C37.1, R39.2, U$12.4 (PGND), U$12.12 (GND), U$13.P$8 (8.VSS), U$13.P$10 (10.BS0), U$13.P$12 (12.BS2), U$13.P$13 (13.CS#), U$13.P$15 (15.D/C#), U$13.P$16 (16.R/W#), U$13.P$17 (17.E/RD#), U$13.P$21 (21.D3), U$13.P$22 (22.D4), U$13.P$23 (23.D5), U$13.P$24 (24.D6), U$13.P$25 (25.D7), U$13.P$29 (29.VLSS); also elsewhere on the board
I2C2_SCL: R11.1, U$12.2 (SCL); also elsewhere on the board
I2C2_SDA: R12.1, U$12.3 (SDA); also elsewhere on the board
I2C3_SCL: R41.2, U$13.P$18 (18.D0); also elsewhere on the board
I2C3_SDA: R40.1, U$13.P$19 (19.D1), U$13.P$20 (20.D2); also elsewhere on the board
INT_EXTI12: R13.1, U$12.13 (INT); also elsewhere on the board
MCU_3V3: R11.2, R12.2, R13.2, R40.2, R41.1, U$12.9 (R_LED+), U$12.10 (IR_LED+); also elsewhere on the board
unnamed: C1.2, R38.2, U$13.P$14 (14.RES#)
unnamed: C2.1, U$13.P$3 (3.C2N)
unnamed: C36.1, U$13.P$5 (5.C1N)
unnamed: C2.2, U$13.P$2 (2.C2P)
unnamed: C36.2, U$13.P$4 (4.C1P)
unnamed: R39.1, U$13.P$26 (26.IREF)
unnamed: C3.2, U$13.P$27 (27.VCOMH)
unnamed: C37.2, U$13.P$28 (28.VCC)
VCC: R38.1, U$13.P$6 (6.VBAT), U$13.P$9 (9.VDD), U$13.P$11 (11.BS1); also elsewhere on the board

Notices in the files:
parts and their libraries:
SparkFun-Resistors: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
